# IAR project I2C_GCMode_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC126AE series Nuvoton NUC126AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC029xGE\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_GCMode_Master.bin
  ILINK.IlinkOutputFile: I2C_GCMode_Master.out
  ILINK.IlinkIcfFile: I2C_GCMode_Master.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/IAR/: startup_NUC029xGE.s
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
