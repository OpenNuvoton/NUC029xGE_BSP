# Keil uVision project FMC_ExeInSRAM.uvproj, settings and files
target FMC_ExeInSRAM (ARM-ADS)
  device: NUC126VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_ExeInSRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: oTime=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029xGE\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\scatter.scf
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/ARM/: startup_NUC029xGE.s
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c retarget.c uart.c clk.c sys.c
