# Keil uVision project PDMA_ScatterGather_PingPongBuffer.uvproj, settings and files
target PDMA_ScatterGather_PingPongBuffer (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: NUC029SGE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: PDMA_ScatterGather_PingPongBuffer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\NUC029xGE\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC029xGE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/ARM/: startup_NUC029xGE.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c pdma.c retarget.c uart.c
