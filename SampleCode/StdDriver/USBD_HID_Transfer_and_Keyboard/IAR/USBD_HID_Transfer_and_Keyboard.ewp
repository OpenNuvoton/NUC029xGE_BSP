# IAR project USBD_HID_Transfer_and_Keyboard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029GE series Nuvoton NUC029GE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029xGE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_Transfer_and_Keyboard.bin
  ILINK.IlinkOutputFile: USBD_HID_Transfer_and_Keyboard.out
  ILINK.IlinkIcfFile: USBD_HID_Transfer_and_Keyboard.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/IAR/: startup_NUC029xGE.s
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c usbd.c
  group User
    ../: descriptors.c HID_Transfer_and_Keyboard.c main.c
