# IAR project PWM_DoubleBuffer_PeriodLoadingMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC126AE series Nuvoton NUC126AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029xGE\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_DoubleBuffer_PeriodLoadingMode.bin
  ILINK.IlinkOutputFile: PWM_DoubleBuffer_PeriodLoadingMode.out
  ILINK.IlinkIcfFile: PWM_DoubleBuffer_PeriodLoadingMode.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/IAR/: startup_NUC029xGE.s
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pwm.c retarget.c sys.c uart.c
  group User
    ../: main.c
