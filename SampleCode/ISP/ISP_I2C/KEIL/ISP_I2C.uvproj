# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC029SGE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: ISP_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029xGE\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/ARM/: startup_NUC029xGE.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c i2c_transfer.c
