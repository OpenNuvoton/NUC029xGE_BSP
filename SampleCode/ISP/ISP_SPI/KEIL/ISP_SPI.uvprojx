# Keil uVision project ISP_SPI.uvprojx, settings and files
target ISP_SPI (6220000::V6.22::ARMCLANG)
  device: NUC029SGE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.27
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC029xGE\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC029xGE.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/: system_NUC029xGE.c
    ../../../../Library/Device/Nuvoton/NUC029xGE/Source/ARM/: startup_NUC029xGE.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c
